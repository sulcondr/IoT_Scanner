<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>capture_freq</value></param>
<param><key>value</key><value>868e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0</value></param>
<param><key>bandwidth</key><value>125000</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>capture_freq</value></param>
<param><key>channel_list</key><value>[868.1e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>7</value></param>
</block>
<block>
<key>lora_message_socket_sink</key>
<param><key>id</key><value>lora_message_socket_sink_0</value></param>
<param><key>ip</key><value>127.0.0.1</value></param>
<param><key>layer</key><value>1</value></param>
<param><key>port</key><value>5005</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>capture_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>rtl_tcp=localhost:7373</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5001</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_msg_sink</key>
<param><key>id</key><value>zeromq_push_msg_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5002</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>frames</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>zeromq_push_msg_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>rtlsdr_source_1</source_block_id><sink_block_id>lora_lora_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
