<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sigfox_receive_realtime</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_first</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_second</value></param>
<param><key>value</key><value>250</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>firdes.low_pass(1,samp_rate,100,50,firdes.WIN_HAMMING)</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pll_freqdet_cf</key>
<param><key>id</key><value>analog_pll_freqdet_cf_0</value></param>
<param><key>w</key><value>6.28/100</value></param>
<param><key>max_freq</key><value>6.28*110e3/samp_rate</value></param>
<param><key>min_freq</key><value>-6.28*110e3/samp_rate</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_1_1_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>threshold</key><value>-20</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_1_1_7</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_1_1_8</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_1_1_9</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0_1_1</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0_1</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_1_1_7</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_1_1_8</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_1_1_9</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0_0_1_1_7</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0_0_1_1_8</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0_0_1_1_9</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_7</value></param>
<param><key>w</key><value>6.28/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_8</value></param>
<param><key>w</key><value>6.28/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_9</value></param>
<param><key>w</key><value>6.28/100</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0_0_1_1_7</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0_0_1_1_8</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0_0_1_1_9</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>decim_second</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>decim_second</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_1</value></param>
<param><key>decim</key><value>decim_second</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_7</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>decim_first</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_8</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>decim_first</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_9</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>decim_first</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>1</value></param>
<param><key>freq0</key><value>868.110000e6</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>1</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>sigfox_Detection_Peak</key>
<param><key>id</key><value>sigfox_Detection_Peak_0</value></param>
<param><key>Scale</key><value>samp_rate/6.28</value></param>
<param><key>Threshold</key><value>90</value></param>
</block>
<block>
<key>sigfox_packet_sink_scapy</key>
<param><key>id</key><value>sigfox_packet_sink_scapy_0_1_1_7</value></param>
</block>
<block>
<key>sigfox_packet_sink_scapy</key>
<param><key>id</key><value>sigfox_packet_sink_scapy_0_1_1_8</value></param>
</block>
<block>
<key>sigfox_packet_sink_scapy</key>
<param><key>id</key><value>sigfox_packet_sink_scapy_0_1_1_9</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>analog_simple_squelch_cc_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_freqdet_cf_0</source_block_id><sink_block_id>sigfox_Detection_Peak_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_1_1_0</source_block_id><sink_block_id>analog_pll_freqdet_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_1_1_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_1_1_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_1_1_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_1_1_7</source_block_id><sink_block_id>digital_binary_slicer_fb_0_1_1_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_1_1_8</source_block_id><sink_block_id>digital_binary_slicer_fb_0_1_1_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_1_1_9</source_block_id><sink_block_id>digital_binary_slicer_fb_0_1_1_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_1_1_7</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0_0_1_1_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_1_1_8</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0_0_1_1_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_1_1_9</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0_0_1_1_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0_0_1_1_7</source_block_id><sink_block_id>blocks_complex_to_real_0_1_1_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0_0_1_1_8</source_block_id><sink_block_id>blocks_complex_to_real_0_1_1_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0_0_1_1_9</source_block_id><sink_block_id>blocks_complex_to_real_0_1_1_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_7</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_8</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_9</source_block_id><sink_block_id>fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0_0_1_1_7</source_block_id><sink_block_id>sigfox_packet_sink_scapy_0_1_1_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0_0_1_1_8</source_block_id><sink_block_id>sigfox_packet_sink_scapy_0_1_1_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0_0_1_1_9</source_block_id><sink_block_id>sigfox_packet_sink_scapy_0_1_1_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0_0_1_1_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0_0_1_1_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_1</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0_0_1_1_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_7</source_block_id><sink_block_id>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_8</source_block_id><sink_block_id>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_8</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_9</source_block_id><sink_block_id>digital_costas_loop_cc_0_0_0_0_0_0_0_1_2_1_1_1_9</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>analog_simple_squelch_cc_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigfox_Detection_Peak_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out0</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sigfox_Detection_Peak_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_7</sink_block_id><source_key>out0</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>sigfox_Detection_Peak_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out1</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sigfox_Detection_Peak_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_8</sink_block_id><source_key>out1</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>sigfox_Detection_Peak_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out2</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sigfox_Detection_Peak_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_9</sink_block_id><source_key>out2</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>sigfox_packet_sink_scapy_0_1_1_7</source_block_id><sink_block_id>blocks_message_debug_0_0_0_1_1</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sigfox_packet_sink_scapy_0_1_1_7</source_block_id><sink_block_id>blocks_socket_pdu_0_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>sigfox_packet_sink_scapy_0_1_1_8</source_block_id><sink_block_id>blocks_message_debug_0_0_0_1_1</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sigfox_packet_sink_scapy_0_1_1_8</source_block_id><sink_block_id>blocks_socket_pdu_0_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>sigfox_packet_sink_scapy_0_1_1_9</source_block_id><sink_block_id>blocks_message_debug_0_0_0_1_1</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sigfox_packet_sink_scapy_0_1_1_9</source_block_id><sink_block_id>blocks_socket_pdu_0_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
